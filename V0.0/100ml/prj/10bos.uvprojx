# Keil uVision project 10bos.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 10BOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\SRC\INC\LIB_INC;..\SRC\INC\OS_INC;..\SRC\BSP;..\SRC\SYSTEM;..\SRC\UNIT\LCD320240
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SYSTEM
    ../SRC/BSP/: stm32f10x_it.c
    ../SRC/SYSTEM/: Main.c Interface.c
    ../src/system/: pump_system.h communication.c flash.c
  group LIB
    ../SRC/LIB/: STM32LIB35.lib STM32UCOSLIB.lib
  group BSP
    ../SRC/BSP/: stm32f10x_conf.h startup_stm32f10x_hd.s system_stm32f10x.c NVIC.c RCC.c AD.c GPIO.c include.h PWM.c TIM.c Usart.c SPI.c
  group UNIT
    ../src/unit/oled/: oled.c
    ../src/unit/lcd320240/: font_data.c tg320240.c
    ../src/unit/pressure/: pressure.c
    ../src/unit/pumpcontrol/: pump.c
  group algorithm
    ../src/algorithm/: pid.c
software components: CMSIS:CORE 4.1.0
